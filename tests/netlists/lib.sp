.lib mylib
r1 1 2 1e3
v1 1 2 1
.endl
